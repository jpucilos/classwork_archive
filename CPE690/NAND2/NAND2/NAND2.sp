********************************************************************************
* SPICE netlist generated by HiPer Verify's NetList Extractor
*
* Extract Date/Time:	Wed Sep 05 14:18:36 2018
* L-Edit Version:		L-Edit Win64 16.03.20130808.06:16:22
*
* Rule Set Name:
* TDB File Name:		E:\git\classwork_archive\CPE690\CMOS_Tutorial.tdb
* Command File:		E:\git\classwork_archive\CPE690\Generic_180nm.ext
* Cell Name:			NAND2
* Write Flat:			NO
********************************************************************************

.include mosis_tsmc_180nm_18.model
.options gmin=1E-9
Vvdd vdd 0 dc 3
Vvss vss 0 dc 0
VinA A 0 dc 0 pulse 0 3 0ns 10ps 10ps 25ns 50ns
VinB B 0 dc 0 pulse 0 3 12ns 10ps 10ps 25ns 50ns
cout Z 0 500fF
.tran .1ns 100ns
.print v(A) v(B) v(Z)
****************************************

M1 1 A VSS VSS NMOS l=1.8e-007 w=3.6e-007 ad=9.72e-014 as=1.62e-013 pd=9e-007 ps=1.62e-006  $ (0.27 0.54 0.45 0.9)
M2 Z B 1 VSS NMOS l=1.8e-007 w=3.6e-007 ad=1.62e-013 as=9.72e-014 pd=1.62e-006 ps=9e-007  $ (0.99 0.54 1.17 0.9)
M3 Z A VDD VDD PMOS l=1.8e-007 w=7.2e-007 ad=1.944e-013 as=3.24e-013 pd=1.26e-006 ps=2.34e-006  $ (0.27 2.7 0.45 3.42)
M4 VDD B Z VDD PMOS l=1.8e-007 w=7.2e-007 ad=3.24e-013 as=1.944e-013 pd=2.34e-006 ps=1.26e-006  $ (0.99 2.7 1.17 3.42)
* Top level device count
* M(NMOS)		2
* M(PMOS)		2
* Number of devices:	4
* Number of nodes:	6
